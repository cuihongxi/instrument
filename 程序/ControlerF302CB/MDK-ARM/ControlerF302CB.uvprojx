# Keil uVision project ControlerF302CB.uvprojx, settings and files
target ControlerF302CB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F302CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ControlerF302CB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F302xC
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\..\HARD;..\..\HARD\AD7147;..\..\HARD\CUIGUI\COLOR;..\..\HARD\CUIGUI\FONT;..\..\HARD\CUIGUI\LCDDRIVER;..\..\HARD\MODBUS;..\..\HARD\OLED;..\..\HARD\TASK;..\..\MENU;..\..\HARD\CUIGUI\CONFIG;..\..\HARD\AD5662;..\..\HARD\STMFLASH
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f302xc.s
  group Application/User
    ../Src/: main.c gpio.c dma.c freertos.c spi.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f3xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group UHEAD
    ../../HARD/: UHEAD.H
  group DRIVER
    ../../HARD/AD7147/: AD7147_Spi.c
    ../../HARD/OLED/: OLED12864.c
    ../../MENU/: DLinkList.c
    ../../HARD/AD5662/: AD5662.c
    ../../HARD/STMFLASH/: stmflash.c
  group FONT
    ../../HARD/CUIGUI/FONT/: songti12.c songti36.c songti24.c song48.c
  group MIDDLEWARES
    ../../HARD/CUIGUI/FONT/: GUI.C
    ../../MENU/: MENU.C
    ../../HARD/CUIGUI/LCDDRIVER/: CUIGUI_LCDDRIVER.C
  group TASK
    ../../HARD/TASK/: TASK_PROJECT.C GUI_TASK.C KEYSCAN_TASK.C MODBUS_REQ_TASK.C MODBUS_RSP_TASK.C PWM_TASK.C
  group MENU
    ../../MENU/: DATAVIEW.C LISTVIEW.C
  group MODBUS
    ../../HARD/MODBUS/: CRC16.C MODBUS.C MODBUS_CONFIG.C MODBUS_REQ.C MODBUS_RSP.C README.TXT
software components: CMSIS:CORE 4.3.0
